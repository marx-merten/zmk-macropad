## config/boards/shields/cd_macropad/Kconfig.defconfig
```kconfig
if SHIELD_CF_MACROPAD

    config ZMK_KEYBOARD_NAME
        default "My Board"

endif
```
